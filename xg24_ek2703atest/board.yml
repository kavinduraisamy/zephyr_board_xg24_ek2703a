## xg24_ek2703atest/board.yml
```yaml
board:
  name: xg24_ek2703atest
  full_name: EFR32xG24 2.4 GHz 20 dBm (xG24-RB4187C)
  vendor: silabs
  socs:
    - name: efr32mg24b220f1536im48
```
